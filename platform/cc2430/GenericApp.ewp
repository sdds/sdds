# IAR project GenericApp.ewp, settings and files
configuration CoordinatorDB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: CC2430DB; xREFLECTOR; xZTOOL_P2; xMT_TASK; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; DATASOURCE
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2430DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430DB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\SOURCE\sDDS\include\sDDS; ..\SOURCE\sDDS\include\DDS; ..\SOURCE\sDDS\src; ..\SOURCE\sDDS\include
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430.xcl
configuration CoordinatorEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; REFLECTOR; ZTOOL_P1; MT_TASK; xMT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2430DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
configuration RouterDB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430DB; xREFLECTOR; xZTOOL_P2; xMT_TASK; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; DATASINK
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; REFLECTOR; ZTOOL_P1; MT_TASK; MT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG
  ICC8051.CCIncludePath2: as above
configuration EndDeviceDB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430DB; NWK_AUTO_POLL; REFLECTOR; xZTOOL_P2; xMT_TASK; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; xPOWER_SAVING
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2430DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430DB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; NWK_AUTO_POLL; REFLECTOR; ZTOOL_P1; MT_TASK; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING
  ICC8051.CCIncludePath2: as above
  group App
    ../Source/: GenericApp.c GenericApp.h OSAL_GenericApp.c
  group App/sDDS/include
    ../Source/sDDS/include/sDDS/: AddressDB.h DataSink.h DataSource.h Locator.h LocatorDB.h Log.h Marshalling.h Memory.h Msg.h NetBuffRef.h NetFrameBuff.h Network.h RecvStateMachine.h sDDS.h SendState.h SNPS.h SourceQos.h TimeMng.h Topic.h TopicDB.h TopicMarshalling.h sdds_types.h
    ../Source/sDDS/src/: CONSTANTS.h
    ../Source/sDDS/include/DDS/: DDS_DCPS.h
    ../Source/sDDS/include/: Foo.h
  group App/sDDS/src
    ../Source/sDDS/src/sDDS/: DataSink.c DataSource.c LocatorDB.c Log.c Marshalling.c Memory.c Msg.c NetBuffRef.c sDDS.c SNPS.c Topic.c TopicDB.c UDP.c ZigBee.c
    ../Source/sDDS/src/: gen_Foo_sDDS.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430DB/Config
    ../../../../../Components/hal/target/CC2430DB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430DB/Drivers
    ../../../../../Components/hal/target/CC2430DB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    ../../../../../Components/hal/target/CC2430DB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_sdds_types.h
  group HAL/Target/CC2430EB/Config
    ../../../../../Components/hal/target/CC2430EB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430EB/Drivers
    ../../../../../Components/hal/target/CC2430EB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430EB/Includes
    ../../../../../Components/hal/target/CC2430EB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_sdds_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT_AF.c MT_AF.h MT_NWK.c MT_NWK.h MT_ZDO.c MT_ZDO.h MTEL.c MTEL.h SPIMgr.c SPIMgr.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c OSAL_Nv.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL.h OSAL_Custom.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2430DB/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2430DB/: chipcon_cexit.s51 chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
